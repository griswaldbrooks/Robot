# IAR project HETdemo.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: TMS470R1B1M TexasInstruments TMS470R1B1M
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\Configuration_Files\B1M_Files\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: HETdemo.out
  ILINK.IlinkIcfFile: C:\Program Files\IAR Systems\Embedded Workbench 6.0 Evaluation\arm\examples\TexasInstruments\Configuration_Files\B1M_Files\tms470r1b1m_lnk_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: cstartup.s main.c pwm.het tms470r1b1m_low_level_init_flash.c
