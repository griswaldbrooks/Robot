# IAR project TOGGLE.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: TMS470R1B1M TexasInstruments TMS470R1B1M
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\Configuration_Files\B1M_Files\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TOGGLE.srec
  ILINK.IlinkOutputFile: TOGGLE.out
  ILINK.IlinkIcfFile: ..\..\Configuration_Files\B1M_Files\tms470r1b1m_lnk_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\Configuration_Files\B1M_Files\tms470r1b1m_lnk_flash.icf
  group (top)
    ./: cstartup.s tms470r1b1m_01.c tms470r1b1m_low_level_init_flash.c
