# IAR project sr_tms.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMS470R1B1M TexasInstruments TMS470R1B1M
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: sr_tms.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\examples\TexasInstruments\Configuration_Files\B1M_Files\tms470r1b1m_lnk_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: B1M_HET_UART_2X115200_H.het B1M_HET_UART_2X115200_Int.c cstartup.s sci.c
